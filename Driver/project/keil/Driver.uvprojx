# Keil uVision project Driver.uvprojx, settings and files
target Driver (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Driver +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\project;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_exti.c
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
